FILESEXTRAPATHS:prepend := "${THISDIR}/base-files:"

SRC_URI:append:unipi-edge = " file://fstab"

