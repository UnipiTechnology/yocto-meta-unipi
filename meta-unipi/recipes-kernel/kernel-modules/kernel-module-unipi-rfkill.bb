
require kernel-module-unipi.inc

# For backwards compatibility
PROVIDES += "kernel-module-unipi-rfkill"

S = "${WORKDIR}/git/modules/unipi-rfkill"
