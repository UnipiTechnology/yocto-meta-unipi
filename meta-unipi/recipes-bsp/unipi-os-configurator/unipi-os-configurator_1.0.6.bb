require unipi-os-configurator-1.0.inc

SRCREV = "f730c756912c592cd27624040a79605301682ba0"
SRC_URI = "git://github.com/UniPiTechnology/os-configurator;protocol=https;branch=main"
