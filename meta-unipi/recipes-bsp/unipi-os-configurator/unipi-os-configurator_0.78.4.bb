require unipi-os-configurator.inc

SRCREV = "2bcaf22483c3fa68939369729d4c24b8b5c06495"
SRC_URI = "git://git.unipi.technology/UniPi/os-configurator/unipi-os-configurator;protocol=https;branch=dev-trixie"

