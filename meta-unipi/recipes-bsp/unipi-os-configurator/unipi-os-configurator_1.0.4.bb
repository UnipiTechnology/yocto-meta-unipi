require unipi-os-configurator-1.0.inc

SRCREV = "9c8c44deb79f187a4f144a3a2aebb9604414f3cf"
SRC_URI = "git://github.com/UniPiTechnology/os-configurator;protocol=https;branch=main"
