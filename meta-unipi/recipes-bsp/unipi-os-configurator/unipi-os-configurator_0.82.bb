require unipi-os-configurator.inc

SRCREV = "2f94a06b86f811226c10118e0602b577a085f112"
SRC_URI = "git://github.com/UniPiTechnology/os-configurator;protocol=https;branch=main"
