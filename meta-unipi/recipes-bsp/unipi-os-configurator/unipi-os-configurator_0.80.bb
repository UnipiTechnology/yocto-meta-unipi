require unipi-os-configurator.inc

SRCREV = "90b1cdd4c6aa897bcd74d71d3fe314934bfa72f4"
SRC_URI = "git://github.com/UniPiTechnology/os-configurator;protocol=https;branch=main"
