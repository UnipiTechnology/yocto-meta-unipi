LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=fed54355545ffd980b814dab4a3b312c"

require unipi-tools.inc

SRCREV = "627d023c77ea10a822296a3bc2ac1afc5dc26d64"


