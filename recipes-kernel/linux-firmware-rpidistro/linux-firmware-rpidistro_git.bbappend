FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "\
  file://0002-CM40-43455-firmware-to-standard-variant.patch\
"